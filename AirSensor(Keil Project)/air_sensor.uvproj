# Keil uVision project air_sensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: air_sensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: main.c uart.c iic.c SGP30.c delay.c SHT3X.c test.c oled.c gui.c ADC.c 8266.c
  group inc
    ./: uart.h iic.h SGP30.h delay.h SHT3X.h test.h oledfont.h oled.h gui.h bmp.h
